FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_dlink-dns320 = " file://0001-dns320-duplicate-dns325-and-run-sed.patch"

